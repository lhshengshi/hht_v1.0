# Keil uVision project project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --diag_suppress=870
  c include: ..\Libraries\ST_Library\CMSIS\Include;..\Libraries\ST_Library\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\ST_Library\STM32F4xx_StdPeriph_Driver\inc;..\User\User\Inc;..\User\User_BSP;..\User\User_BSP\BSP_Inc;..\User\User_BSP\BSP_Usart2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/User/Src/: main.c Utility.c stm32f4xx_it.c
  group User BSP
    ../User/User_BSP/BSP_Src/: BSP.c BSP_PutOut.c
  group MDK-ARM
    ../Libraries/ST_Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/ST_Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group BSP_Internet
    ../User/User_BSP/BSP_Internet/W5500/: w5500.c W5500_Conf.c W5500_Socket.c W5500_SPI.c
  group StdPeriph_Driver
    ../Libraries/ST_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_spi.c
  group BSP_Usart2
    ../User/User_BSP/BSP_Usart2/: BSP_Usart2.c
