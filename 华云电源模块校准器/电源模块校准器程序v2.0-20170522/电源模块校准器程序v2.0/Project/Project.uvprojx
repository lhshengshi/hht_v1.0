# Keil uVision project Project.uvprojx, settings and files
target STM32F1 工程模板 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User\User\Inc;..\User\User_BSP\BSP\Usart;..\User\User_BSP_Demo\Inc;..\User\User_BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/User/Src/: main.c Utility.c stm32f10x_it.c
  group User/BSP
    ../User/User_BSP/Src/: BSP_OutPut.c User_BSP.c beep.c key.c BSP_JCM12864.c BSP_JCM12864_Demo.c TIM3_Dirver.c LED_Dirver.c Usart3_Dirver.c EEprom_Dirver.c CN3153.c ADC.c
  group Driver/FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_adc.c
  group MDK-ARM/CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
